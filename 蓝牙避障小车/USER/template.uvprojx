# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\HARDWARE\EXTI;..\HARDWARE\LED;..\HARDWARE\MOTOR;..\HARDWARE\PWM;..\HARDWARE\TIM;..\SYSTEM\DELAY;..\SYSTEM\SYS;..\HARDWARE\HC-SR04;..\HARDWARE\OLED;..\HARDWARE\Bluetooth;..\HARDWARE\MEROBOTICARM;..\HARDWARE\PS2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/DELAY/: DELAY.c
    ../SYSTEM/SYS/: SYS.c
  group HARDWARE
    ../HARDWARE/EXTI/: EXTI.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/MOTOR/: MOTOR.c
    ../HARDWARE/PWM/: PWM.c
    ../HARDWARE/TIM/: TIM.c
    ../HARDWARE/HC-SR04/: HCSR04.c
    ../HARDWARE/OLED/: OLED.c OLED_Data.c
    ../HARDWARE/Bluetooth/: Bluetooth.c
    ../HARDWARE/MEROBOTICARM/: MEROBOTICARM.c
    ../HARDWARE/PS2/: PS2.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
