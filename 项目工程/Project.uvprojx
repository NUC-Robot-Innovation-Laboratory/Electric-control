# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\start;.\SYSTEM\DELAY;.\SYSTEM\DS18B20;.\SYSTEM\ESP8266;.\SYSTEM\KEY;.\SYSTEM\LED;.\SYSTEM\SYS;.\SYSTEM\TIMER;.\SYSTEM\USART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./USER/: main.cpp
  group SYSTEM
    ./SYSTEM/DELAY/: delay.c delay.h
    ./SYSTEM/DS18B20/: ds18b20.c ds18b20.h
    ./SYSTEM/ESP8266/: esp8266.c esp8266.h
    ./SYSTEM/KEY/: key.c key.h
    ./SYSTEM/LED/: led.c led.h
    ./SYSTEM/SYS/: sys.c sys.h
    ./SYSTEM/TIMER/: timer.c timer.h
    ./SYSTEM/USART/: usart.c usart.h
